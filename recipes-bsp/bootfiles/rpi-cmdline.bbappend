CMDLINE:append = " systemd.getty_auto=no console=tty1"
